options:
  parameters:
    generate_options: qt_gui
    id: uat_receiver
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: freq
  id: variable
  parameters:
    value: 978e6
  states: {}
- name: fsk_deviation_hz
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 3e6
  states: {}
- name: xfir_bw_hz
  id: variable
  parameters:
    value: 900e3
  states: {}
- name: xfir_decimation
  id: variable
  parameters:
    value: '3'
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '10'
  states: {}
- name: analog_simple_squelch_cc_0_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: '-40'
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: freq
    decim: '1'
    samp_rate: samp_rate
    taps: ' firdes.low_pass(1,samp_rate,samp_rate/(2*xfir_decimation), xfir_bw_hz)'
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: 900e3
    fc: '0'
    fftsize: '1024'
    tr_level: '-90'
    tr_mode: qtgui.TRIG_MODE_NORM
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    autoscale: 'True'
    bw: 4e6
    fc: '0'
    fftsize: '1024'
    freqhalf: 'False'
    tr_level: '-90'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    tr_level: '0.5'
    tr_mode: qtgui.TRIG_MODE_NORM
    tr_slope: qtgui.TRIG_SLOPE_NEG
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    update_time: '0.001'
    wintype: window.WIN_FLATTOP
  states: {}
- name: soapy_rtlsdr_source_0
  id: soapy_rtlsdr_source
  parameters:
    center_freq: freq
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0_0, '0', digital_binary_slicer_fb_0, '0']
- [analog_simple_squelch_cc_0_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [analog_simple_squelch_cc_0_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_simple_squelch_cc_0_0, '0', qtgui_waterfall_sink_x_0_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_uchar_to_float_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_simple_squelch_cc_0_0, '0']
- [soapy_rtlsdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
